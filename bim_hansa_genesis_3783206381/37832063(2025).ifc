Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 4ee71998-7a6e-489f-a289-5877b0e1d862, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 37832063(2025).ifc
Time: 2025-11-19T21:58:35+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENU) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_24162_1
InPort_24162_2

# IfcFlowTerminal: 37832063(2025):37832063 Bath faucet, floor mounting, 37832063(2025):37832063 Bath faucet, floor mounting:24162
In: Level 1
Type - Material: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 37832063(2025); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 37832063; Name: 37832063 Bath faucet, floor mounting; ReplacementCost: n/a; Shape: Sculptured; Size: 175x295x955 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 294.507 mm; NominalHeight: 955.69 mm; NominalWidth: 173 mm
Type - General - Author: BIMStone; BIMObjectName: 37832063(2025); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 2025/11/20
Type - Green Building Properties - EN Standard: EN 817; ETIM Class Number: EC010862 Bath mixing tap; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/37832063; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 3D View: https://static.hansa.com/3D/37832063; Catalog Drawing URL: http://static.hansa.com/catdrw/37832063; Category B2C: Bathtub & Shower; Color variants: 3783206333;3783206380;3783206381; Dimension Drawing URL: http://static.hansa.com/dimdrw/37832063; FDV Document URL: http://www.hansa.com/datasheet/37832063/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/37832063; Group: Bath faucet; Interactive AR View URL: https://static.hansa.com/AR/37832063; Manufacturer: HANSA; Market: International;Poland;Germany;Austria;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.hansa.com/37832063; Model: 37832063 Bath faucet, floor mounting; Name_en: 37832063 Bath faucet, floor mounting; OmniClass Number: 23.31.17.00; OmniClass Title: Showers; Product Code: 37832063; Product Family: HANSAGENESIS; Product Image URL: http://static.hansa.com/image/37832063; Product URL: http://static.hansa.com/37832063; Spare-Part Information URL: http://static.hansa.com/sp/37832063; Technical DataSheet URL: http://www.hansa.com/datasheet/37832063/en; Type Name: 37832063 Bath faucet, floor mounting; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Aerator: Hidden aerator;PCA® - constant flow rate regardless of pressure variations;Adjustable flow angle; Backflow Prevention EN1717: EB; Concealed Parts: Round rosette; Connection Size: G1/2; Diverter: Pull operated diverter;Automatic reset; Flow Rate At 300kPa: 0.4 dm3/s; Hand Shower: Hand shower; Hand Shower Size: Ø25 mm; Installation Type: Floor standing; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 90 C; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Shower Parts: Hand shower;Shower holder;Shower hose (1250 mm); Shower Spray Number: 1 spray function; Spout Projection: 209 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 37832063; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 37832063 Bath faucet, floor mounting
Material: <Unnamed>, Chrome
Pset_DistributionFlowElementCommon - Reference: 37832063 Bath faucet, floor mounting; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 37832063(2025); Family and Type: 37832063(2025): 37832063 Bath faucet, floor mounting; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 37832063 Bath faucet, floor mounting; Type Id: 24140; WarrantyStartDate: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.498841 m2; Volume: 0.0486968 m3
Identity Data - Mark: 10
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction
